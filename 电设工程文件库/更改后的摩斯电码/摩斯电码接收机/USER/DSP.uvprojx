# Keil uVision project DSP.uvprojx, settings and files
target DSP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\USMART;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\DSPLIB\Include;..\HARDWARE\ADF4002;..\HARDWARE\OLED;..\HARDWARE\AD9851
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c numc.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_nand.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADF4002/: adf4002.c
    ../HARDWARE/OLED/: oled.c myiic.c
    ../HARDWARE/AD9851/: AD9851.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group DSPLIB
    ../DSPLIB/: arm_cortexM7lfdp_math.lib
  group README
    ../: readme.txt
