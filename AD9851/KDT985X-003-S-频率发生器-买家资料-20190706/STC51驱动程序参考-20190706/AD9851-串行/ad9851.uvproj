# Keil uVision project ad9851.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: ad9851 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ad9851.c
